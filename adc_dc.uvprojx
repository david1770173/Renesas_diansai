# Keil uVision project adc_dc.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: adc_dc
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\applications;.\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Applications
    ./applications/: app_adc.c
  group Drivers
    ./drivers/: drv_adc.c drv_uart.c hal_systick.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c bsp_dht11.c bsp_dht11.h
software components: Flex Software:RA Configuration 1.0.0
